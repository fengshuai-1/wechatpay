# Keil uVision project gd32.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32E103RB GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gd32 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USBFS,GD32E10X GD32E103V_EVAL,__TARGET_FPU_VFP,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_CM4,__CC_ARM
  c include: ..\Driver\CMSIS\GD\GD32E10x\Include;..\UserCode\inc;..\Driver\GD32E10x_standard_peripheral\Include;..\Driver\GD32E10x_usbfs_driver\Include;..\Bsp\inc;..\UserCode\inc;..\Driver\CMSIS;..\QRCODE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../Driver/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
    ../Driver/CMSIS/GD/GD32E10x/Source/ARM/: startup_gd32e10x.s
  group GD32E103_Driver
    ../Driver/GD32E10x_standard_peripheral/Source/: gd32e10x_adc.c gd32e10x_bkp.c gd32e10x_can.c gd32e10x_crc.c gd32e10x_ctc.c gd32e10x_dac.c gd32e10x_dbg.c gd32e10x_dma.c gd32e10x_exmc.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_fwdgt.c gd32e10x_gpio.c gd32e10x_i2c.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_rtc.c gd32e10x_spi.c gd32e10x_timer.c gd32e10x_usart.c gd32e10x_wwdgt.c
  group BSP
    ../BSP/src/: bsp.c bsp_user_lib.c bsp_gpio.c bsp_rtc.c bsp_lcd.c bsp_spi.c bsp_debug.c bsp_timer.c bsp_usb.c ziku.c bsp_uart.c bsp_lock.c bsp_n58.c bsp_gps.c
  group UserCode
    ../UserCode/src/: main.c gd32e10x_it.c Lcd_GUI.c cdc_acm_core.c md5.c n58.c key.c menu.c
  group GD32E10X_EVAL
    ../UserCode/src/: gd32e10x_eval.c
  group USB Device Lib
    ../Driver/GD32E10x_usbfs_driver/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
  group Doc
    ../Doc/: readme.txt
  group QRCODE
    ../QRCODE/: bitstream.c mask.c mmask.c mqrspec.c QR_Encode.c qrencode.c qrinput.c qrspec.c rscode.c split.c
